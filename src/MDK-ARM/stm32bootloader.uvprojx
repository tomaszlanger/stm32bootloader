# Keil uVision project stm32bootloader.uvprojx, settings and files
target stm32bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stm32bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Inc;        ../Drivers/STM32L0xx_HAL_Driver/Inc;        ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;        ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: flash.c bootloader.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
